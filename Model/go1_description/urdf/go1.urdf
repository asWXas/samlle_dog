Commit message: 1

File: Model/go1_description/urdf/go1.urdf (robot description, URDF)
Before this commit: robot go1, 46 links, 45 joints
Links:
- link trunk: mass 5.204 -> 13.204
